FILESEXTRAPATHS_prepend := "${THISDIR}/4.4:"
SRC_URI_append = " file://0001-ptrace-fixup-for-crash-handler.patch"
